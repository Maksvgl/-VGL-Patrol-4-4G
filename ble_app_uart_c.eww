<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10040\s132\iar\ble_app_uart_c_pca10040_s132.ewp</path>
    </project>
    <batchBuild />
</workspace>
